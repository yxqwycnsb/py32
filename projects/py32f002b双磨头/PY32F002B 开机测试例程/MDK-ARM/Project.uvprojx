# Keil uVision project Project.uvprojx, settings and files
target PY32F002Bx5_Project (5060528::V5.06 update 5 (build 528)::ARMCC)
  device: PY32F002Bx5 Puya
  pack: Puya.PY32F0xx_DFP.1.1.7
  cpu: IRAM(0x20000000,0x00000C00) IROM(0x08000000,0x00006000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: Project +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: USE_HAL_DRIVER,PY32F002Bx5
  c include: ..\User;..\CMSIS\Include;..\CMSIS\Device\PY32F0xx\Include;..\PY32F002B_HAL_Driver\Inc;..\BSP_Drivers;..\ProtoThread-Core-main;..\ProtoThread-Core-main\sys;..\ProtoThread-Core-main\lib;..\ProtoThread-Core-main\transplant_ports;..\User
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x6000
  memory RVCT9: RAM 0x20000000 size 0xc00
  group Common
    ../User/: system_py32f002b.c startup_py32f002xx.s
  group Application/User
    ../User/: main.c py32f002b_it.c py32f002b_hal_msp.c bsp_ws2812b.c
  group PY32F002B_HAL_Driver
    ../PY32F002B_HAL_Driver/Src/: py32f002b_hal.c py32f002b_hal_adc.c py32f002b_hal_comp.c py32f002b_hal_cortex.c py32f002b_hal_crc.c py32f002b_hal_exti.c py32f002b_hal_flash.c py32f002b_hal_gpio.c py32f002b_hal_i2c.c py32f002b_hal_iwdg.c py32f002b_hal_lptim.c py32f002b_hal_pwr.c py32f002b_hal_rcc.c py32f002b_hal_rcc_ex.c py32f002b_hal_spi.c py32f002b_hal_tim.c py32f002b_hal_tim_ex.c py32f002b_hal_uart.c py32f002b_hal_usart.c
  group Bsp_Drivers
    ../BSP_Drivers/Bsp_Led/: Bsp_Led.c
    ../BSP_Drivers/Bsp_Key/: Bsp_Key.c
    ../BSP_Drivers/Bsp_Uart/: Bsp_Uart.c
  group Doc
    ../: readme.txt
  group ProtoThread-Core-main
    ../ProtoThread-Core-main/: protothread.c
    ../ProtoThread-Core-main/transplant_ports/: pt_ports.c
    ../ProtoThread-Core-main/sys/: ctimer.c etimer.c process.c timer.c
    ../ProtoThread-Core-main/lib/: list.c memb.c ringbuf.c
software components: CMSIS:CORE 5.1.2
